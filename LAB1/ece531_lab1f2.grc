options:
  parameters:
    generate_options: qt_gui
    id: ece531_lab1b
    output_language: python
    title: ece531_lab1b
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: magnitude
  id: variable_qtgui_range
  parameters:
    label: magnitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '6.2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1000'
    step: '200'
    stop: '40000'
    value: '10000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_IMPULSE
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '32000'
    type: complex
  states: {}
- name: channels_iqbal_gen_0
  id: channels_iqbal_gen
  parameters:
    mag: magnitude
    mode: '0'
    phase: phase
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Time
    label1: Frequency
    num_tabs: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_complex_to_real_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_throttle_0, '0', channels_iqbal_gen_0, '0']
- [channels_iqbal_gen_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
